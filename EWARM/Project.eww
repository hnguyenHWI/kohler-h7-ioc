<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ws_cubemx_wifi_stack_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
